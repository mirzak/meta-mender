FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://10_bootargs_grub.cfg;subdir=git"
